# IAR project Bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F072RB ST STM32F072RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F072xB; USE_HAL_DRIVER; USE_FULL_LL_DRIVER
  ICCARM.CCDiagSuppress: Pe546
  ICCARM.CCIncludePath2: ..\..\..\common_src\drivers\drv_ext; ..\..\..\common_src\drivers\drv_int; ..\..\..\common_src\drivers\drv_stm32f0_hal\STM32F0xx_HAL_Driver\Inc; ..\..\..\common_src\drivers\drv_stm32f0_hal\CMSIS\Device\ST\STM32F0xx\Include; ..\..\..\common_src\drivers\drv_stm32f0_hal\CMSIS\Include; ..\..\..\common_src\services; ..\source\applications; ..\source\config; ..\source\services; $PROJ_DIR$
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Bootloader.bin
  ILINK.IlinkOutputFile: user.out
  ILINK.IlinkIcfFile: stm32f072xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F051R8 ST STM32F051R8
  ICCARM.CCDefines: HSE_VALUE=((uint32_t)8000000); USE_STDPERIPH_DRIVER; STM32F072
  ICCARM.CCIncludePath2: ..\stm32f0_std_libarary; ..\stm32f0_std_libarary\STM32F0xx_StdPeriph_Driver\inc; ..\stm32f0_std_libarary\cmsis; ..\stm32f0_std_libarary\cmsis\iar; ..\periph_driver; ..\periph_driver\framework; ..\periph_driver\framework\bsp; ..\periph_driver\framework\drv; ..\periph_driver\framework\system; ..\periph_driver\system_config
  OBJCOPY.OOCOutputFile: led_lighting_engine.srec
  ILINK.IlinkOutputFile: led_lighting_engine.out
  group app
    ./: main.c stm32f072xb_flash.icf
    ../source/applications/: stm32f0xx_it.c
  group app/sys_config
    ../source/config/: system_platform_config.h
  group drv/common/bsp
    ../../../common_src/drivers/drv_int/: f0_bsp_flash.c f0_bsp_led.c f0_bsp_usart.c f0_systick_delay.c
  group drv/common/system
    ../../../common_src/services/: sys_fifo.c system_poll_timer.c ymodem.c
  group drv/stm32
    ../source/config/: stm32f0xx_hal_conf.h system_stm32f0xx.c
  group drv/stm32/boot
    ../../../common_src/drivers/drv_stm32f0_hal/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f072xb.s
  group drv/stm32/lib
    ../../../common_src/drivers/drv_stm32f0_hal/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_ll_dma.c stm32f0xx_ll_exti.c stm32f0xx_ll_gpio.c stm32f0xx_ll_pwr.c stm32f0xx_ll_rcc.c stm32f0xx_ll_spi.c stm32f0xx_ll_usart.c stm32f0xx_ll_utils.c
